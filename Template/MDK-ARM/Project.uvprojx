# Keil uVision project Project.uvprojx, settings and files
target GD32F503V_EVAL (6220000::V6.22::ARMCLANG)
  device: GD32F503VG GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F50X, GD32F503, FW_DEBUG_ERR_REPORT, GD32F5xx_FlexColor, LVGL_API_VERSION=8
  c include: ..\..\Firmware\CMSIS\GD\GD32F50x\Include;..\..\Firmware\CMSIS;..\..\Firmware\GD32F50x_standard_peripheral\Include;..\..\Utilities\BSP_Drive;..\..\Utilities;..;..\..\Utilities\Third_Party\lvgl\lvgl_src;..\..\Utilities\Third_Party\lvgl\port;..\..\Utilities\Third_Party\lvgl\demos\widgets;..\..\Utilities\Third_Party\lvgl\lvgl_src\src;..\..\Utilities\Third_Party\lvgl\lvgl_src\src\draw\sw;..\..\Utilities\Third_Party\lvgl\lvgl_src\src\misc
  asm include: ..\..\Firmware\CMSIS\GD\GD32F50x\Include;..\..\Firmware\CMSIS;..\..\Firmware\GD32F50x_standard_peripheral\Include;..\..\Utilities\BSP_Drive;..\..\Utilities;..;..\..\Utilities\Third_Party\lvgl\lvgl_src;..\..\Utilities\Third_Party\lvgl\lvgl_src\src;..\..\Utilities\Third_Party\lvgl\lvgl_src\src\misc;..\..\Utilities\Third_Party\lvgl\lvgl_src\src\draw\sw;..\..\Utilities\Third_Party\lvgl\demos\widgets
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../: main.c systick.c gd32f50x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F50x/Source/: system_gd32f50x.c gd32f50x_err_report.c
  group GD32F50x_Peripherals
    ../../Firmware/GD32F50x_standard_peripheral/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
  group BSP_Drive
    ../../Utilities/BSP_Drive/: gd32f503v_eval.c gd32f503v_lcd_eval.c touch_panel.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F50x/Source/ARM/: startup_gd32f50x.s
  group lvgl/src/core
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group lvgl/src/extra
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/bmp/: lv_bmp.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/freetype/: lv_freetype.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/: lv_extra.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/gridnav/: lv_gridnav.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/imgfont/: lv_imgfont.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/monkey/: lv_monkey.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/msg/: lv_msg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/others/snapshot/: lv_snapshot.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/led/: lv_led.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/list/: lv_list.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/span/: lv_span.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/extra/widgets/win/: lv_win.c
  group lvgl/src/misc
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/src/font
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/port
    ../../Utilities/Third_Party/lvgl/port/: lv_port_disp.c lv_port_indev.c
  group lvgl/demo
    ../../Utilities/Third_Party/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../../Utilities/Third_Party/lvgl/demos/widgets/: lv_demo_widgets.c
  group lvgl/src/hal
    ../../Utilities/Third_Party/lvgl/lvgl_src/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
software components: CMSIS:CORE 5.3.0
